# Keil uVision project lonely.uvproj, settings and files
target simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lonely
  group boot
    ../../../machines/thumb2/cortex-m3/: Startup_GCC.s STM32F10x_GCC.s
  group trampoline
    ../../../debug/: tpl_debug.c
  group trampoline_thumb2
    ../../../machines/thumb2/: tpl_machine_arm_generic.c tpl_system_call.S
    ../../../machines/thumb2/cortex-m3/: cm3_tpl_stubs.c cm3_tpl_sleep.S
    ../../../os/: tpl_os_action.c tpl_os_alarm_kernel.c tpl_os_error.c tpl_os_event_kernel.c tpl_os_it_kernel.c tpl_os_kernel.c tpl_os_rez_kernel.c tpl_os_task_kernel.c tpl_os_timeobj_kernel.c tpl_os.c
  group generated
    ./lonely/: tpl_app_config.c tpl_dispatch_table.c tpl_invoque.S
  group app
    ./: lonely.c
  group oil
    ./lonely/: script.ld
    ./: lonely.oil
